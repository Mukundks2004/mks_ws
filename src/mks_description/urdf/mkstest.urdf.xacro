Commit message: yay

File: src/mks_description/urdf/mkstest.urdf.xacro (robot description, xacro)
@@ -64,5 +64,5 @@
     <child link="link_2"/>
     <origin xyz="0 0 0.5"/>
-    <axis xyz="0 0 1"/>
+    <axis xyz="0 1 1"/>
   </joint>
 </robot>
